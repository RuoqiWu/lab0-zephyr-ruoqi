## blinky/tests/BME280_TEST/testcase.yaml
```yaml
tests:
  bme280.registers:
    platform_allow:
      - qemu_cortex_m3
    tags:
      - bme280
      - unit
    harness: ztest
```
